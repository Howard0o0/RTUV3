# IAR project RTUV01.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlsfn.h
  General.OGChipSelectMenu: MSP430F5438A MSP430F5438A
  General.GStackSize2: 2048
  General.GHeapSize2: 2500
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: F:\ZHIJIANG
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  A430.AUserIncludes: F:\ZHIJIANG
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430f5438a.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.newCCIncludePaths: F:\RTUV10; F:\BaiduNetdiskDownload\2，标准例程-HAL库版本\实验3 串口通信实验\USER\hydrology-protocol
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430f149.xcl
  group (top)
    ./: adc.c BC95.c BC95.h blueTooth.c common.c communicateManager.c Console.c debug.c dtu.c GSM.c GTM900C.c hydrologycommand.c hydrologytask.c led.c main.c message.c packet.c rom.c rtc.c Sampler.c store.c timer.c uart0.c uart1.c uart1.h uart2.c uart2.h uart3.c uart3.h uart_config.c wifi_config.c
