# IAR project Backup (2) of RTUV01.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlsfn.h
  General.OGChipSelectMenu: MSP430F2418 MSP430F2418
  General.GStackSize2: 2048
  General.GHeapSize2: 2500
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: F:\BaiduNetdiskDownload\2，标准例程-HAL库版本\实验3 串口通信实验\USER\hydrology-protocol; F:\RTUV10
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430f5438a.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.newCCIncludePaths: F:\RTUV10; F:\BaiduNetdiskDownload\2，标准例程-HAL库版本\实验3 串口通信实验\USER\hydrology-protocol
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430f149.xcl
  group (top)
    ./: adc.c common.c Console.c debug.c dtu.c GSM.c GTM900C.c hydrologytask.c led.c main.c Sampler.c
    ../BaiduNetdiskDownload/2，标准例程-HAL库版本/实验3 串口通信实验/USER/hydrology-protocol/: hydrologycommand.c message.c
    Debug/Exe/: RTUV01.r43
