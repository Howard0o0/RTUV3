# IAR project Backup of RTUV01.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430F2418 MSP430F2418
  General.GStackSize2: 2048
  General.GHeapSize2: 2500
  General.RadioHeapSizeType: 0
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F2418.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group (top)
    ./: adc.c adc.h common.c common.h Console.c Console.h debug.c debug.h dtu.c dtu.h flash.c flash.h flow.c flow.h GPRS.c GPRS.h GSM.c GSM.h hydrology.c hydrology.h led.c led.h main.c main.h msp430common.h packet.c packet.h reportbinding .c reportbinding.h reportdata.h rom.c rom.h rtc.c rtc.h Sampler.c Sampler.h store.c store.h timer.c timer.h uart0.c uart0.h uart1.c uart1.h wifi_config.c wifi_config.h
